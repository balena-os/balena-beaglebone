FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Changed-the-behavior-of-the-wlan_en-regulator-3-to-r.patch"

