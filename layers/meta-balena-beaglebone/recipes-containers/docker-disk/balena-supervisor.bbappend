LED_FILE:beaglebone = "/sys/class/leds/beaglebone\:green\:usr3/brightness"
