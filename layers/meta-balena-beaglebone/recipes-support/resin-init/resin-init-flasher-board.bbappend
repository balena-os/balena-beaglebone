FILESEXTRAPATHS:append:beaglebone-ai64 := "${THISDIR}/${PN}-beaglebone-ai64"
FILESEXTRAPATHS:append:beagleplay := "${THISDIR}/${PN}-beagleplay"