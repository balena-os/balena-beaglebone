CONNECTIVITY_FIRMWARES:append = " linux-firmware-wl18xx"
