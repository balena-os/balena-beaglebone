#
# Beaglebone has some specific requirements for dtc in order to compile the
# overlays
#

SRCREV = "1ef86ad2c24f67567b1021ca5cb84bea82749f88"

